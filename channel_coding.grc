<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>channel_coding</value></param>
<param><key>author</key><value>Alireza Khayyatiyan</value></param>
<param><key>description</key><value>AUT:bachelor thesis</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>channel_coding</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es</value></param>
<param><key>value</key><value>sum(numpy.square(constellation))/(len(constellation)/(1.0*dim))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>EsN0_dB</value></param>
<param><key>value</key><value>3</value></param>
<param><key>label</key><value>Es/N0 (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation</value></param>
<param><key>value</key><value>mod[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dim</value></param>
<param><key>value</key><value>mod[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsm_i</value></param>
<param><key>value</key><value>trellis.fsm(prefix+"/awgn2o3_4.fsm")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsm_i</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>trellis.fsm(prefix+"/awgn1o1_16rsc.fsm")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsm_o</value></param>
<param><key>value</key><value>trellis.fsm(prefix+"/awgn1o2_4.fsm")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsm_o</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>trellis.fsm(prefix+"/awgn1o1_4rsc.fsm")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsm_o1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>trellis.fsm(prefix+"/awgn1o2_4.fsm")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsm_o2</value></param>
<param><key>value</key><value>trellis.fsm(prefix+"/awgn1o2_16.fsm")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interleaver</value></param>
<param><key>value</key><value>trellis.interleaver(block,666)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod</value></param>
<param><key>value</key><value>fu.psk2x3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1,[-1,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noisevar</value></param>
<param><key>value</key><value>10**(-EsN0_dB/10.0)  * Es   /2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"C:/Program Files/GNURadio-3.7/share/gnuradio/examples/trellis/fsm_files"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noisevar**0.5</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>-42</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0_0</value></param>
<param><key>amp</key><value>noisevar**0.5</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>-42</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1007</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1007</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>type</key><value>'SER'</value></param>
<param><key>win_size</key><value>block*100</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>R</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>R</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>dim</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>constellation</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>dim</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>constellation</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import gnuradio.trellis.fsm_utils as fu</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>BER</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"BER"</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fsm_args</key><value>fsm_i</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>type</key><value>bb</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fsm_args</key><value>fsm_o</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>type</key><value>bb</value></param>
</block>
<block>
<key>trellis_metrics_x</key>
<param><key>id</key><value>trellis_metrics_x_0_0</value></param>
<param><key>table</key><value>constellation</value></param>
<param><key>dim</key><value>dim</value></param>
<param><key>metric_type</key><value>digital.TRELLIS_EUCLIDEAN</value></param>
<param><key>card</key><value>2**dim</value></param>
<param><key>type</key><value>f</value></param>
</block>
<block>
<key>trellis_permutation</key>
<param><key>id</key><value>trellis_permutation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interleaver_size</key><value>interleaver.K()</value></param>
<param><key>syms_per_block</key><value>1</value></param>
<param><key>table</key><value>interleaver.INTER()</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>trellis_sccc_decoder_x</key>
<param><key>id</key><value>trellis_sccc_decoder_x_0</value></param>
<param><key>block_size</key><value>block</value></param>
<param><key>i_fsm_args</key><value>fsm_i</value></param>
<param><key>i_final_state</key><value>-1</value></param>
<param><key>i_init_state</key><value>0</value></param>
<param><key>interleaver</key><value>trellis.interleaver(block,666)</value></param>
<param><key>iterations</key><value>10</value></param>
<param><key>o_fsm_args</key><value>fsm_o</value></param>
<param><key>o_final_state</key><value>-1</value></param>
<param><key>o_init_state</key><value>0</value></param>
<param><key>out_type</key><value>b</value></param>
<param><key>siso_type</key><value>trellis.TRELLIS_MIN_SUM</value></param>
</block>
<block>
<key>trellis_sccc_encoder_xx</key>
<param><key>id</key><value>trellis_sccc_encoder_xx_0</value></param>
<param><key>bl</key><value>block</value></param>
<param><key>i_fsm_args</key><value>fsm_i</value></param>
<param><key>i_init_state</key><value>0</value></param>
<param><key>interleaver_args</key><value>interleaver</value></param>
<param><key>o_fsm_args</key><value>fsm_o</value></param>
<param><key>o_init_state</key><value>0</value></param>
<param><key>type</key><value>bb</value></param>
</block>
<block>
<key>trellis_sccc_encoder_xx</key>
<param><key>id</key><value>trellis_sccc_encoder_xx_0_0</value></param>
<param><key>bl</key><value>block</value></param>
<param><key>i_fsm_args</key><value>fsm_i</value></param>
<param><key>i_init_state</key><value>0</value></param>
<param><key>interleaver_args</key><value>interleaver</value></param>
<param><key>o_fsm_args</key><value>fsm_o2</value></param>
<param><key>o_init_state</key><value>0</value></param>
<param><key>type</key><value>bb</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>info1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>info2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1</value></param>
<param><key>stream_id</key><value>usr1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>usr2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>usr1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>info1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>usr2</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>virtual_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>trellis_encoder_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>trellis_sccc_encoder_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>trellis_sccc_encoder_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_0_0</source_block_id><sink_block_id>trellis_permutation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_metrics_x_0_0</source_block_id><sink_block_id>trellis_sccc_decoder_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_permutation_0</source_block_id><sink_block_id>trellis_encoder_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_sccc_decoder_x_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>trellis_sccc_encoder_xx_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_sccc_encoder_xx_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>trellis_metrics_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
